Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-10-11T07:57:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.2.90.12 - Alternate UI 20.2.90.12
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 11 07:57:25 2023 * Host: BIMServices * Database: C:\Users\PIOTRB~1\AppData\Local\Temp\f417ea85-6b6b-487b-86c9-a28277fa1a04\c7d59877-8d3b-422b-8524-395de095bb2f\ifc * Database version: 5507 * Database creation date: Wed Oct 11 07:57:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 11 07:57:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 11 07:57:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection
2 x Port_314969 | SOURCE
2 x Port_314969 | SINK

# IfcFlowController: InLineThermalDisinfectionUnitILTDU, NBS_HorneEngineeringLtd_ThrmlDsnfctnUnits_InLineThermalDisinfectionUnit:InLineThermalDisinfectionUnitILTDU:314969
In: Level 0
Type - PredefinedType: USERDEFINED; Material: NBS_HorneEngineeringLtd_Bronze, NBS_HorneEngineeringLtd_Steel
Type - BOS_General - Author: NBS; BIMObjectName: NBS_HorneEngineeringLtd_ThermalDisinfectionUnits_InLineThermalDisinfectionUnitILTDU; ManufacturerName: Horne Engineering Ltd; ManufacturerURL: www.horne.co.uk; ProductInformation: https://source.thenbs.com/product/-/3e60b146-53d4-4f67-a1d4-3ee8a2ae3229/deebfbda-624a-451b-9a54-0fee8848ea60; Uniclass2015Title: Thermal disinfection units; Uniclass2015Code: Pr_60_55_97_90; Uniclass2015Version: Products v1.31; Version: 1
Type - NBS_Data - Accessories: Operation Key P/N 6236; Certification: UK Water Reg 4; Connections: Hot and cold, 15 mm compression; CountryOfProductManufacture: United Kingdom; Materials: Brass alloy body, nitrile/PTFE seals, stainless steel four way link mechanism; Recyclability: Can be recycled; WaterPressure: Maximum working pressure (static): 10 bar
Type - IFC - IfcExportAs: IfcValveType; IfcExportType: USERDEFINED
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_55_97_90:Thermal disinfection units; CodePerformance: n/a; Color: Silver,Bronze; Constituents: n/a; Description: In-line thermal disinfection unit for tap or shower outlets; DurationUnit: year; ExpectedLife: n/a; Features: Facilitates periodic high temperature thermal disinfection using the readily available hot water supply; Finish: Metallic,Etched; Grade: n/a; Manufacturer: specifications@horne.co.uk; Material: Brass,Stainless steel,Plastic,Polymer; ModelNumber: ILTDU; ModelReference: In-line Thermal Disinfection Unit; Name: ThermalDisinfectionUnits_InLineThermalDisinfectionUnitILTDU_HorneEngineeringLtd; NominalHeight: 89 mm; NominalLength: 147 mm; NominalWidth: 53 mm; ReplacementCost: n/a; Shape: Other; Size: 15 mmø-15 mmø-15 mmø-15 mmø; SustainabilityPerformance: n/a; WarrantyDescription: Two year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
